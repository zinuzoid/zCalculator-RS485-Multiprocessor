# IAR project zOS.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F100xB ST STM32F100xB
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_MD_VL
  ICCARM.CCIncludePath2: src; ..\..\STM32F10x_StdPeriph_Lib_V3.4.0\Libraries\CMSIS\CM3\CoreSupport; ..\..\STM32F10x_StdPeriph_Lib_V3.4.0\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x; ..\..\STM32F10x_StdPeriph_Lib_V3.4.0\Libraries\STM32F10x_StdPeriph_Driver\inc
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: zOS.srec
  ILINK.IlinkOutputFile: c.out
  ILINK.IlinkIcfFile: stm32f100xb.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  OBJCOPY.OOCOutputFile: c.srec
  group CMSIS
    ../../STM32F10x_StdPeriph_Lib_V3.4.0/Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../../STM32F10x_StdPeriph_Lib_V3.4.0/Project/STM32F10x_StdPeriph_Template/: system_stm32f10x.c
  group header
    src/: button.h cmd.h header.h led.h queue.h roundrobintask.h rs485protocal.h stack.h stm32f10x_conf.h stm32f10x_it.h systick.h usart.h util.h
  group src
    src/: button.c cmd.c led.c main.c queue.c roundrobintask.c rs485protocal.c stack.c systick.c usart.c util.c
    ../../STM32F10x_StdPeriph_Lib_V3.4.0/Project/STM32F10x_StdPeriph_Template/: stm32f10x_it.c
  group Startup
    ../../STM32F10x_StdPeriph_Lib_V3.4.0/Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/iar/: startup_stm32f10x_md_vl.s
  group StdPeriph
    ../../STM32F10x_StdPeriph_Lib_V3.4.0/Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c
